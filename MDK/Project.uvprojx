# Keil uVision project Project.uvprojx, settings and files
target Project (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: CW32F030C8 WHXY
  pack: WHXY.CW32F030_DFP.1.0.1
  cpu: IRAM(0x20000000,0x02000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: HK821C +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=output\bin\@L.bin !L
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 wLevel=2
  c define: BOARD_CW32F030CX
  c include: ..\Libraries\inc;..\USER\inc;..\PRV;..\IT6635_OK_LEE20191108;..\IT6635_OK_LEE20191108\chip;..\IT6635_OK_LEE20191108\Customer;..\ITE_6635_OK_LBY20230608_DUAL;..\ITE_6635_OK_LBY20230608_DUAL\chip;..\ITE_6635_OK_LBY20230608_DUAL\Customer
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --keep=*Handler
  group Startup
    ../IdeSupport/MDK/: startup_cw32f030.s
    ../Libraries/src/: system_cw32f030.c
  group User
    ../USER/src/: main.c interrupts_cw32f030.c gpio.c uart.c tim.c
    ../PRV/: delay.c sim_i2c.c
  group Driver
    ../Libraries/src/: cw32f030_adc.c cw32f030_atim.c cw32f030_awt.c cw32f030_btim.c cw32f030_crc.c cw32f030_debug.c cw32f030_digitalsign.c cw32f030_dma.c cw32f030_flash.c cw32f030_gpio.c cw32f030_gtim.c cw32f030_i2c.c cw32f030_iwdt.c cw32f030_lvd.c cw32f030_pwr.c cw32f030_ram.c cw32f030_rcc.c cw32f030_rtc.c cw32f030_spi.c cw32f030_systick.c cw32f030_uart.c cw32f030_vc.c cw32f030_wwdt.c
software components: CMSIS:CORE 5.4.0
